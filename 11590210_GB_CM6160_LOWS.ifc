Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 689625a4-226f-4854-a9da-e13b89519e6d, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T08:46:06+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11590210_GB_CM6160_LOWS:29616001_GB_11590210_CM6160_LOWS, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, <Unnamed>, z_Miele_Design_OBSW, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_CLST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 251 mm; Height: 359 mm; Depth: 427 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 29616001_GB_11590210_CM6160_LOWS; sets with these values: 2
